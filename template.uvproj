# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c drive.c fp_module.c uart.c drive.h fp_module.h uart.h main.h common.c common.h i2c.c i2c.h ds1302.c lcd.c ds1302.h lcd.h
